# Keil uVision project charlcd.uvproj, settings and files
target CharLCD (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: charlcd
  c flags: Optim=3
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32f10x_md_vl.s
  group Application
    ./: char_lcd.c char_lcd_functions.c retarget.c
  group CMSIS
    ./: system_stm32f10x.c
