# Keil uVision project Blinky.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: blinky.c
  group CMSIS
    ./: system_LPC43xx.c
  group Startup
    ./: startup_LPC43xx.s
