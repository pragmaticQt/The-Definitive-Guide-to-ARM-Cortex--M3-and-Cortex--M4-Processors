# Keil uVision project blinky.uvproj, settings and files
target Debug (ARM-GNU)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky
  group Startup
    ./: startup_stm32f4xx.S
  group Application
    ./: blinky.c
  group CMSIS
    ./: system_stm32f4xx.c
