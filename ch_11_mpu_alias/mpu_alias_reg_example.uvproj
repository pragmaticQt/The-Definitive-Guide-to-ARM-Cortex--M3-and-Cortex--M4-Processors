# Keil uVision project mpu_alias_reg_example.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: mpu_alias_reg_example
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
  group CMSIS
    ./: system_stm32f4xx.c
  group Retarget
    ./: retarget.c
  group Application
    ./: mpu_alias_example.c
