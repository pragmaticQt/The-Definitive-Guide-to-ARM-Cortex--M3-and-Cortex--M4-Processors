# Keil uVision project DTMF.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DTMF +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4, ARM_MATH_CM4, __FPU_PRESENT=1
  c include: C:\Keil\ARM\Device\ARM\ARMCM4\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: ../../../ARM/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib
  group Startup Files
    C:/Keil/ARM/Device/ARM/ARMCM4/Source/: system_ARMCM4.c
    C:/Keil/ARM/Device/ARM/ARMCM4/Source/ARM/: startup_ARMCM4.s
  group Source Files
    ./: DTMF.c
